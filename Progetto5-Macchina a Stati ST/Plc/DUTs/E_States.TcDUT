{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_States :
(
	eStop := 0,
	eGreen,
	eYellow,
	eRed
);
END_TYPE
